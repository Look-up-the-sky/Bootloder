# Keil uVision project bootloader.uvprojx, settings and files
target Target 1 (5050106::V5.05 update 1 (build 106)::ARMCC)
  device: STM32F070CB STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.5.0
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x4000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: bootloader
  c flags: Optim=2 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c misc: --c99
  c include: .\Include;.\LibStm32\Header
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group USER
    ./Code/: main.c Flash.c Usart.c Jump_to_app.c Check.c IAP_Data.c Modbus.c GPIO.c Timer.c Display.c config.c startup_stm32f070xb.s
  group LIB
    ./LibStm32/Source/: stm32f0xx_rcc.c stm32f0xx_usart.c stm32f0xx_tim.c system_stm32f0xx.c stm32f0xx_gpio.c stm32f0xx_flash.c stm32f0xx_misc.c stm32f0xx_syscfg.c
